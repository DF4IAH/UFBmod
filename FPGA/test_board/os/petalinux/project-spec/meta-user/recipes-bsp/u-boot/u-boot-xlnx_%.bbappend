FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2019-02-14-07-51-00.cfg \
            file://user_2019-02-14-14-48-00.cfg \
            "
